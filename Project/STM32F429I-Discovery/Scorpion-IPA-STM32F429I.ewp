# IAR project Scorpion-IPA-STM32F429I.ewp, settings and files
configuration STM32F429I-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\Include\STM32F429I-Discovery; ..\..\Libraries\BSP\STM32F429I-Discovery; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F4xx_HAL_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Scorpion-IPA-STM32F429I.hex
  ILINK.IlinkOutputFile: Scorpion-IPA-STM32F429I.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../Source/STM32F429I-Discovery/: system_stm32f4xx.c
  group Components
    ../../Libraries/BSP/Components/mt9m111/: mt9m111.c
  group STM32F429I-Discovery
    ../../Libraries/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_camera.c
  group STM32F4xx_HAL_Driver
    ../../Libraries/STM32F4xx_HAL_Driver/src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group User
    ../../Source/STM32F429I-Discovery/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c ub_timer.c ub_uart.c
