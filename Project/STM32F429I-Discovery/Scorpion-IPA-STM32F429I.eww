<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Scorpion-IPA-STM32F429I.ewp</path>
  </project>
  <batchBuild/>
</workspace>


